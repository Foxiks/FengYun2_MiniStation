options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FengYun2_Demodulator
    output_language: python
    run_options: run
    title: FengYun2 Demodulator
  states: {}

blocks:
- name: sps
  id: variable
  parameters:
    value: (samp_rate_rx*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 660e3
  states: {}
- name: amp
  id: parameter
  parameters:
    type: intx
    value: '14'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: costas_loop_bw
  id: parameter
  parameters:
    type: eng_float
    value: '0.002'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '8.7e-3'
    gain_omega: 8.7e-3**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.000005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop_bw
  states: {}
- name: driver
  id: parameter
  parameters:
    type: str
    value: hackrf=0
  states: {}
- name: fengyun2_decoder_0
  id: fengyun2_decoder
  parameters:
    path: out_path
  states: {}
- name: fengyun2_diff_decoder_0
  id: fengyun2_diff_decoder
  parameters: {}
  states: {}
- name: fengyun2_sync_derand_0
  id: fengyun2_sync_derand
  parameters:
    threshold: threshold
  states: {}
- name: lna
  id: parameter
  parameters:
    type: intx
    value: '40'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: int(354848/8)
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver
    bb_gain0: vga
    bw0: samp_rate_rx
    freq0: rx_freq
    gain0: amp
    gain_mode0: 'False'
    if_gain0: lna
    sample_rate: samp_rate_rx
    sync: sync
    type: fc32
  states: {}
- name: out_path
  id: parameter
  parameters:
    type: str
    value: '"/home/user/Documents/FY-2-Images/"'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.50'
    decim: '1'
    gain: '1'
    ntaps: '31'
    samp_rate: samp_rate_rx
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 16875e5
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: 20e5
  states: {}
- name: threshold
  id: parameter
  parameters:
    type: intx
    value: '7'
  states: {}
- name: udp_frames_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {}
- name: vga
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_real_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [digital_binary_slicer_fb_0_0, '0', fengyun2_diff_decoder_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [fengyun2_diff_decoder_0, '0', fengyun2_sync_derand_0, '0']
- [fengyun2_sync_derand_0, '0', fengyun2_decoder_0, '0']
- [fengyun2_sync_derand_0, '0', network_udp_sink_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
